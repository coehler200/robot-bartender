# Keil uVision project mixingrobot.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mixingrobot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
    ./modules/: menu.c menu.h power.c power.h prime.c prime.h dispense.c dispense.h
  group Lib Header
    ./lib/: analog.h clock.h gpio.h interupt.h lcd.h pwm.h rotenc.h functions.h sounds.h
  group Lib Source
    ./lib/: analog.c clock.c gpio.c interupt.c lcd.c pwm.c rotenc.c functions.c sounds.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
